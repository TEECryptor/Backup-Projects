# Keil uVision project Syno_TFCOS_FwLib.uvproj, settings and files
target Syno_TFCOS_FwLib (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: AS568_TF8_SDCard
  c flags: Optim=1
  c define: RSASUPPORT,ECCSUPPORT,_DEBUG,USED_FOR_TF = 1,USE_ONE_FILE
  c include: ..\CMSIS\Core\CM0;..\HAL;..\HDR;..\Source;..\Startup;..\HAL\USB;..\HAL\ALG;..\FatFs;
  scatter file: ..\SY03_FwLib.sct
  link misc: --entry Reset_Handler
  group CMSIS Files
    ../CMSIS/Core/CM0/: core_cm0.c core_cm0.h
  group Startup Files
    ../Startup/: startup_SY03.s system_SY03.c
  group HDR Files
    ../HDR/: SY03_SCM.h SY03_GPIO.h SY03_ACMP.h SY03_BVD.h SY03_CRC.h SY03_EFC.h SY03_RNG.h SY03_ROM.h SY03_RTC.h SY03_SCI.h SY03_SDSI.h SY03_SQI.h SY03_SSI.h SY03_SWPM.h SY03_SWPS.h SY03_USART.h SY03_USB.h SY03_VPWM.h SY03_TMR.h SY03_ISO7816.h Type.h SY03_Device.h SY03_Regs.c
  group HAL Files
    ../HAL/: Efc.c Retarget.c Sci.c Scm.c Serial.c Sqi.c Ssi.c Swpm.c Swps.c Gpio.c Spi.c Uart.c I2c.c Acmp.c Vpwm.c Bvd.c Trng.c Tmr.c Rtc.c Crc.c SFlash.c XFlash.c Acmp.h Bvd.h Crc.h Efc.h Gpio.h I2c.h Rtc.h Sci.h Scm.h Sdsi.h SFlash.h Spi.h Sqi.h Ssi.h Swpm.h Swps.h SY03.h Tmr.h Trng.h Uart.h Vpwm.h XFlash.h Iso7816.c Iso7816.h Sdsi.c Sdi.c RomFunc.h SY03_RomFunc.lib
  group USB
    ../HAL/USB/: bulkitem.c bulkusb.c bulkusb.h ctrlitem.c CtrlItem.h ctrlusb.c CtrlUsb.h UsbBase.c UsbBase.h usbcont.h USBProtocol.c USBProtocol.h Usb.h
  group ALG
    ../HAL/ALG/: AES.h Alg.h DES.h ECDSA.h MD5.h RSA.h SHA-1.h SHA-256.h SM1.h SM2.h SM3.h SMS4.h SSF33.h SY03_CRYPT.lib
  group Source Files
    ../Source/: main.c SYglobal.h FileSystem.h SY06_FwLib.lib Command.c Command.h SdMemAcc.c SdMemAcc.h log.c log.h SD_SystemApp.c CommandEx.c CommandEx.h SD_SystemApp.h
  group TestAlg
    ../Source/TestAlg/: TestSSF33.c testAes.c TestAlg.c TestDes.c testEcc.c TestHash.c TestRandRom.c TestRSA.c TestSM1.c TestSM2.c TestSM3.c TestSMS4.c
  group FatFS
    ../FatFS/: ff.c ff.h ffconf.h integer.h diskio.c diskio.h
